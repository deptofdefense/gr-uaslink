<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>psk_burst_rx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>burst_size</value></param>
<param><key>value</key><value>288</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable_repetition_decoder_def</key>
<param><key>id</key><value>variable_repetition_decoder_def_0</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>3</value></param>
<param><key>prob</key><value>0.5</value></param>
</block>
<block>
<key>variable_repetition_encoder_def</key>
<param><key>id</key><value>variable_repetition_encoder_def_0</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>3</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/psk_xmit.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_filter</key>
<param><key>id</key><value>blocks_pdu_filter_0</value></param>
<param><key>invert</key><value>False</value></param>
<param><key>k</key><value>pmt.intern("key")</value></param>
<param><key>v</key><value>pmt.intern("value")</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>burst_correlator_filter</key>
<param><key>id</key><value>burst_correlator_filter_0</value></param>
<param><key>l1</key><value>100</value></param>
<param><key>thresh</key><value>-10</value></param>
<param><key>i1</key><value>1e-4</value></param>
</block>
<block>
<key>burst_deframer</key>
<param><key>id</key><value>burst_deframer_0</value></param>
</block>
<block>
<key>burst_framealign</key>
<param><key>id</key><value>burst_framealign_0</value></param>
<param><key>bs</key><value>1024</value></param>
<param><key>skip</key><value>len(pre_bits)</value></param>
</block>
<block>
<key>burst_framer</key>
<param><key>id</key><value>burst_framer_0</value></param>
<param><key>bs</key><value>burst_size</value></param>
</block>
<block>
<key>burst_length_detect</key>
<param><key>id</key><value>burst_length_detect_0</value></param>
</block>
<block>
<key>burst_length_detect_c</key>
<param><key>id</key><value>burst_length_detect_c_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>burst_preamble_correlator</key>
<param><key>id</key><value>burst_preamble_correlator_0</value></param>
<param><key>pre</key><value>pre_bits</value></param>
<param><key>ro</key><value>0.35</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>burst_preamble_insert</key>
<param><key>id</key><value>burst_preamble_insert_0</value></param>
<param><key>pre</key><value>pre_bits</value></param>
</block>
<block>
<key>burst_randomizer</key>
<param><key>id</key><value>burst_randomizer_0</value></param>
<param><key>iv</key><value>[1,0,0,1,0,1,0,1,0,0,0,0,0,0,0]</value></param>
<param><key>ml</key><value>100000</value></param>
<param><key>p</key><value>[0,14,15]</value></param>
</block>
<block>
<key>burst_randomizer</key>
<param><key>id</key><value>burst_randomizer_0_0</value></param>
<param><key>iv</key><value>[1,0,0,1,0,1,0,1,0,0,0,0,0,0,0]</value></param>
<param><key>ml</key><value>100000</value></param>
<param><key>p</key><value>[0,14,15]</value></param>
</block>
<block>
<key>burst_scheduler</key>
<param><key>id</key><value>burst_scheduler_0</value></param>
</block>
<block>
<key>burst_slicer</key>
<param><key>id</key><value>burst_slicer_0</value></param>
</block>
<block>
<key>burst_synchronizer_v4</key>
<param><key>id</key><value>burst_synchronizer_v4_0</value></param>
<param><key>preamble_bits</key><value>pre_bits</value></param>
<param><key>fs</key><value>int(samp_rate)</value></param>
<param><key>sps</key><value>2</value></param>
<param><key>sym_mapping</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0_0</value></param>
<param><key>epsilon</key><value>1.0+random.random()*1e-4</value></param>
<param><key>freq_offset</key><value>random.random()*1e-4</value></param>
<param><key>noise_voltage</key><value>0.05</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>64</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>eb</key><value>asap</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mm</key><value>memcpy</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>length</key><value>burst_size*8</value></param>
<param><key>lookback</key><value>100</value></param>
<param><key>guard</key><value>500</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>thresh</key><value>5</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import pyqt</value></param>
</block>
<block>
<key>mapper_demapper_msg</key>
<param><key>id</key><value>mapper_demapper_msg_0</value></param>
<param><key>modtype</key><value>mapper.QPSK</value></param>
<param><key>symbol_values</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>mapper_mapper_msg</key>
<param><key>id</key><value>mapper_mapper_msg_0</value></param>
<param><key>modtype</key><value>mapper.QPSK</value></param>
<param><key>symbol_values</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_bits</value></param>
<param><key>value</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_bits_0</value></param>
<param><key>value</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>l</key><value>Pre-Sync Syms</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,2</value></param>
<param><key>l</key><value>Final Syms</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1</value></param>
<param><key>l</key><value>Sym CFO Corr</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>l</key><value>Burst Envelope</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,1,2</value></param>
<param><key>l</key><value>Burst Post Length-D</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,2,1,1</value></param>
<param><key>l</key><value>Final Syms</value></param>
</block>
<block>
<key>pyqt_meta_text_output</key>
<param><key>id</key><value>pyqt_meta_text_output_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,2</value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>pyqt_time_plot_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,0</value></param>
<param><key>l</key><value>XCorr Mags</value></param>
<param><key>style</key><value>line</value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>pyqt_time_plot_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>l</key><value>Soft Bits</value></param>
<param><key>style</key><value>dots</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>8192</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value></value></param>
<param><key>yunit</key><value></value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>8192</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*10</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>ntaps</key><value>41</value></param>
<param><key>samp_rate</key><value>2.0</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>uaslink_burst_verification</key>
<param><key>id</key><value>uaslink_burst_verification_0</value></param>
</block>
<block>
<key>uaslink_mavlink_control</key>
<param><key>id</key><value>uaslink_mavlink_control_0</value></param>
<param><key>baud_rate</key><value>57600</value></param>
<param><key>connection_string</key><value>'127.0.0.1:14560'</value></param>
</block>
<block>
<key>uaslink_pdu_control_to_pdu_vector</key>
<param><key>id</key><value>uaslink_pdu_control_to_pdu_vector_0</value></param>
</block>
<block>
<key>uaslink_pdu_vector_to_pdu_control</key>
<param><key>id</key><value>uaslink_pdu_vector_to_pdu_control_0</value></param>
</block>
<block>
<key>uaslink_pymavlink_source_sink_pp</key>
<param><key>id</key><value>uaslink_pymavlink_source_sink_pp_0</value></param>
<param><key>baud_rate</key><value>57600</value></param>
<param><key>connection_string</key><value>'tcp:127.0.0.1:5763'</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:14000'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>burst_preamble_correlator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_correlator_filter_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_correlator_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_correlator_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_deframer_0</source_block_id><sink_block_id>pyqt_meta_text_output_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_deframer_0</source_block_id><sink_block_id>uaslink_burst_verification_0</sink_block_id><source_key>pdus</source_key><sink_key>PDU_IN</sink_key></connection>
<connection><source_block_id>burst_deframer_0</source_block_id><sink_block_id>uaslink_pdu_vector_to_pdu_control_0</sink_block_id><source_key>pdus</source_key><sink_key>Vector_IN</sink_key></connection>
<connection><source_block_id>burst_framealign_0</source_block_id><sink_block_id>burst_slicer_0</sink_block_id><source_key>fpdus</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>burst_framer_0</source_block_id><sink_block_id>burst_randomizer_0_0</sink_block_id><source_key>unpacked_pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_0</source_block_id><sink_block_id>burst_synchronizer_v4_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>burst_synchronizer_v4_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>pyqt_const_plot_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>pyqt_cpower_plot_0_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_preamble_correlator_0</source_block_id><sink_block_id>burst_correlator_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_preamble_insert_0</source_block_id><sink_block_id>mapper_mapper_msg_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_randomizer_0</source_block_id><sink_block_id>burst_deframer_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_randomizer_0_0</source_block_id><sink_block_id>burst_preamble_insert_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_scheduler_0</source_block_id><sink_block_id>es_source_0</sink_block_id><source_key>sched_pdu</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>burst_slicer_0</source_block_id><sink_block_id>burst_randomizer_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>mapper_demapper_msg_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_const_plot_0_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_cpower_plot_0_2</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_const_plot_0_0_0</sink_block_id><source_key>debug_post_cfo</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_time_plot_1</sink_block_id><source_key>debug_pre_xcorr</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>channels_channel_model_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>pdus_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>burst_length_detect_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>burst_length_detect_c_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>pyqt_cpower_plot_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>burst_scheduler_0</sink_block_id><source_key>nproduced</source_key><sink_key>nproduced</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>edge_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>mapper_demapper_msg_0</source_block_id><sink_block_id>burst_framealign_0</sink_block_id><source_key>fpdus</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>mapper_demapper_msg_0</source_block_id><sink_block_id>pyqt_time_plot_1_0</sink_block_id><source_key>fpdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>mapper_mapper_msg_0</source_block_id><sink_block_id>burst_scheduler_0</sink_block_id><source_key>cpdus</source_key><sink_key>sched_pdu</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>channels_channel_model_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uaslink_burst_verification_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>Control_OUT</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>uaslink_mavlink_control_0</source_block_id><sink_block_id>uaslink_pymavlink_source_sink_pp_0</sink_block_id><source_key>MAVLink_OUT</source_key><sink_key>MAVLink_IN</sink_key></connection>
<connection><source_block_id>uaslink_pdu_control_to_pdu_vector_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>Vector_OUT</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>uaslink_pdu_control_to_pdu_vector_0</source_block_id><sink_block_id>burst_framer_0</sink_block_id><source_key>Vector_OUT</source_key><sink_key>packed_pdus</sink_key></connection>
<connection><source_block_id>uaslink_pdu_vector_to_pdu_control_0</source_block_id><sink_block_id>uaslink_mavlink_control_0</sink_block_id><source_key>Control_OUT</source_key><sink_key>Command</sink_key></connection>
<connection><source_block_id>uaslink_pymavlink_source_sink_pp_0</source_block_id><sink_block_id>uaslink_mavlink_control_0</sink_block_id><source_key>MAVLink_OUT</source_key><sink_key>MAVLink_IN</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>uaslink_pdu_control_to_pdu_vector_0</sink_block_id><source_key>out</source_key><sink_key>Control_IN</sink_key></connection>
</flow_graph>
