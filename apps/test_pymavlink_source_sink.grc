<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_pymavlink_source_sink</value></param>
<param><key>description</key><value>This requires a SITL running.  Source a message and send to a sink on another port</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>uaslink_pymavlink_sink_p</key>
<param><key>id</key><value>uaslink_pymavlink_sink_p_0</value></param>
<param><key>baud_rate</key><value>57600</value></param>
<param><key>connection_string</key><value>'tcp:127.0.0.1:5760'</value></param>
</block>
<block>
<key>uaslink_pymavlink_source_p</key>
<param><key>id</key><value>uaslink_pymavlink_source_p_1</value></param>
<param><key>baud_rate</key><value>57600</value></param>
<param><key>connection_string</key><value>'udp:127.0.0.1:14550'</value></param>
</block>
<connection><source_block_id>uaslink_pymavlink_source_p_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>MAVLink</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>uaslink_pymavlink_source_p_1</source_block_id><sink_block_id>uaslink_pymavlink_sink_p_0</sink_block_id><source_key>MAVLink</source_key><sink_key>MAVLink</sink_key></connection>
</flow_graph>
