<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_psk_burst_control_tx_pc</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Used to run on the host PC for communcations with the custom control messages</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>burst_size</value></param>
<param><key>value</key><value>288</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2238300000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>burst_framer</key>
<param><key>id</key><value>burst_framer_0</value></param>
<param><key>bs</key><value>burst_size</value></param>
</block>
<block>
<key>burst_preamble_insert</key>
<param><key>id</key><value>burst_preamble_insert_0</value></param>
<param><key>pre</key><value>pre_bits</value></param>
</block>
<block>
<key>burst_randomizer</key>
<param><key>id</key><value>burst_randomizer_0_0</value></param>
<param><key>iv</key><value>[1,0,0,1,0,1,0,1,0,0,0,0,0,0,0]</value></param>
<param><key>ml</key><value>100000</value></param>
<param><key>p</key><value>[0,14,15]</value></param>
</block>
<block>
<key>burst_scheduler</key>
<param><key>id</key><value>burst_scheduler_0</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>eb</key><value>asap</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mm</key><value>memcpy</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import pyqt</value></param>
</block>
<block>
<key>mapper_mapper_msg</key>
<param><key>id</key><value>mapper_mapper_msg_0</value></param>
<param><key>modtype</key><value>mapper.QPSK</value></param>
<param><key>symbol_values</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_bits</value></param>
<param><key>value</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_bits_0</value></param>
<param><key>value</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab1@2</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>tr_tag</key><value>packet_len</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>1</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab1@1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>gui_hint</key><value>tab1@0</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>2500</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>tr_tag</key><value>packet_len</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>ntaps</key><value>41</value></param>
<param><key>samp_rate</key><value>2.0</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab1</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>label0</key><value>Time</value></param>
<param><key>label1</key><value>Freq.</value></param>
<param><key>label2</key><value>Const.</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>uaslink_pdu_control_to_pdu_vector</key>
<param><key>id</key><value>uaslink_pdu_control_to_pdu_vector_0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, samp_rate/2.0)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"serial=3113A52"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:14000'</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>burst_framer_0</source_block_id><sink_block_id>burst_randomizer_0_0</sink_block_id><source_key>unpacked_pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_preamble_insert_0</source_block_id><sink_block_id>mapper_mapper_msg_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_randomizer_0_0</source_block_id><sink_block_id>burst_preamble_insert_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_scheduler_0</source_block_id><sink_block_id>es_source_0</sink_block_id><source_key>sched_pdu</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>burst_scheduler_0</sink_block_id><source_key>nproduced</source_key><sink_key>nproduced</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_mapper_msg_0</source_block_id><sink_block_id>burst_scheduler_0</sink_block_id><source_key>cpdus</source_key><sink_key>sched_pdu</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uaslink_pdu_control_to_pdu_vector_0</source_block_id><sink_block_id>burst_framer_0</sink_block_id><source_key>Vector_OUT</source_key><sink_key>packed_pdus</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>uaslink_pdu_control_to_pdu_vector_0</sink_block_id><source_key>out</source_key><sink_key>Control_IN</sink_key></connection>
</flow_graph>
